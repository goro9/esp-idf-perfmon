## ota/native_ota_example/sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
CONFIG_PARTITION_TABLE_CUSTOM=y
CONFIG_ESPTOOLPY_BAUD_2MB=y
CONFIG_FREERTOS_GENERATE_RUN_TIME_STATS=y
```
